# Keil uVision project AHRSLibM4.uvproj, settings and files
target AHRSLibM4 (ARM-ADS)
  device: M453VG6AE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: AHRSLibM4 (library)
  c flags: wLevel=2
  c define: M451
  c include: ..\..\..\Library\Device\Nuvoton\M451Series\Include;..\..\..\Library\StdDriver\inc;.\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M451series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
    ../../../Library/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
  group User
    ./: AccCalibrate.c AccFilter.c AHRSLib.c BaroKalman.c Gauss_Newton_Calibrate.c GyroCalibrate.c GyroDriftCalibrate.c Kalman.c MagCalibrate.c Security.c SensorFusion6.c TestCode.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c fmc.c
  group Include
    ./include/: AHRSLib.h
    ./: AccFilter.h Common.h Gauss_Newton_Calibrate.h GyroDriftCalibrate.h Kalman.h Security.h SensorFusion6.h
